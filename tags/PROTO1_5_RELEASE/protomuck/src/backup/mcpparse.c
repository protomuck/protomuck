
/*  A Bison parser, made from mcpparse.y with Bison version GNU Bison version 1.24
  */

#define YYBISON 1  /* Identify Bison output.  */

#define	NUM	258
#define	STR	259
#define	IDENT	260
#define	OBJ	261
#define	COMMENT	262
#define	IFDEF	263
#define	IFNDEF	264
#define	ECHODEF	265
#define	INCLUDE	266
#define	DEFINE	267
#define	UNDEF	268
#define	ENDIF	269
#define	ELSEDEF	270
#define	IF	271
#define	ELSE	272
#define	WHILE	273
#define	DO	274
#define	FOR	275
#define	BREAK	276
#define	CONTINUE	277
#define	RETURN	278
#define	SWITCH	279
#define	CASE	280
#define	DEFAULT	281
#define	SWITCHALL	282
#define	MAKEARRAY	283
#define	TOP	284
#define	PUSH	285
#define	FUNC	286
#define	PUBLIC	287
#define	VAR	288
#define	COMMA	289
#define	BLANK	290
#define	SEMICOLON	291
#define	COLON	292
#define	OPAREN	293
#define	CPAREN	294
#define	OBRACE	295
#define	CBRACE	296
#define	OBRACK	297
#define	CBRACK	298
#define	ASGN	299
#define	OR	300
#define	AND	301
#define	BITOR	302
#define	BITXOR	303
#define	BITAND	304
#define	EQ	305
#define	NE	306
#define	GT	307
#define	GTE	308
#define	LT	309
#define	LTE	310
#define	SHIFTR	311
#define	SHIFTL	312
#define	ADD	313
#define	SUB	314
#define	MUL	315
#define	DIV	316
#define	MOD	317
#define	INCR	318
#define	DECR	319
#define	UNARY	320
#define	NOT	321
#define	CALL	322

#line 1 "mcpparse.y"

/*
 * MCP parser by Joseph Traub and Jeremy Blackman
 * Copyright(C) 1996, Joseph L. Traub and Jeremy Blackman, All rights reserved.
 *
 * This software is part of the NeonMuck distribution and is usable under
 * the terms and conditions of the license attendant with that software.
 *
 * This code is based loosely on ideas and concepts of the MUV grammer written
 * by Russ Smith and Marcus Ranum.
 *
 * This module contains the BNF in YACC for the MCP language, and builds the
 * parse tree which is then translated into MUF.
 */

#include	<stdio.h>
#include	<ctype.h>
#include	<string.h>
#include	<stdlib.h>
#include	"mcpstruct.h"
#include	"copyright.h"

#ifndef TEST
#include "parser.h"
#endif

void yyerror(char *);
void yywarn(char *);

extern int yylex(void);

extern void initMcpParser(void);
extern void writeMcpProgram(FILE *);
extern void clearMem(void);

extern void insertFunction(char *, mcp_piecelist *, mcp_slist *);
extern void insertPublicDecl(char *);
extern void insertDefine(char *, mcp_slist *);
extern void insertComment(char *);
extern void insertDirective(mcp_directive *);
extern void insertVar(int, mcp_piecelist *);

extern mcp_directive *makeDirective(int, char *);

extern mcp_slist *makeStatement(int, mcp_expr *);
extern mcp_slist *makeArrayDecl(char *id, mcp_expr *expr);
extern mcp_slist *makeNull(void);
extern mcp_slist *makeComment(char *);
extern mcp_slist *makeDirectiveStatement(mcp_directive *);
extern mcp_slist *makeIf(mcp_slist *, mcp_slist *, mcp_slist *);
extern mcp_slist *makeLoop(int,mcp_slist *,mcp_slist *,mcp_slist *,mcp_slist *);
extern mcp_slist *appendStatement(mcp_slist *, mcp_slist *);
extern mcp_slist *makeAssign(mcp_piecelist *, mcp_expr *);
extern mcp_slist *makeSwitch(int, mcp_expr *, mcp_caselist *);

extern mcp_expr *makeNumber(int);
extern mcp_expr *makeObject(char *);
extern mcp_expr *makeString(char *);
extern mcp_expr *makeTop(void);
extern mcp_expr *makeIdent(char *);
extern mcp_expr *makePush(mcp_exprlist *);
extern mcp_expr *makeCall(char *, mcp_exprlist *, char *);
extern mcp_expr *makeIncr(int, char *);
extern mcp_expr *makeOp(int, mcp_expr *, mcp_expr *);
extern mcp_expr *makeArrayRef(char *, mcp_expr *);
extern mcp_exprlist *makeExpr(mcp_expr *);
extern mcp_exprlist *appendExpr(mcp_expr *, mcp_exprlist *);

extern mcp_piecelist *makeId(char *);
extern mcp_piecelist *makeArray(char *, mcp_expr *);
extern mcp_piecelist *appendId(mcp_piecelist *, mcp_piecelist *);
extern mcp_piecelist *makeBlank(void);

extern mcp_caselist *makeCase(mcp_expr *, mcp_slist *);
extern mcp_caselist *appendCase(mcp_caselist *, mcp_caselist *);


#line 79 "mcpparse.y"
typedef union {
   int val;
   char *string;
   mcp_directive *dir;
   mcp_slist *stmt;
   mcp_expr *expr;
   mcp_exprlist *elist;
   mcp_piecelist *ilist;
   mcp_caselist *clist;
} YYSTYPE;

#ifndef YYLTYPE
typedef
  struct yyltype
    {
      int timestamp;
      int first_line;
      int first_column;
      int last_line;
      int last_column;
      char *text;
   }
  yyltype;

#define YYLTYPE yyltype
#endif

#include <stdio.h>

#ifndef __cplusplus
#ifndef __STDC__
#define const
#endif
#endif



#define	YYFINAL		259
#define	YYFLAG		-32768
#define	YYNTBASE	68

#define YYTRANSLATE(x) ((unsigned)(x) <= 322 ? yytranslate[x] : 85)

static const char yytranslate[] = {     0,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     2,     2,     2,     2,     2,
     2,     2,     2,     2,     2,     1,     2,     3,     4,     5,
     6,     7,     8,     9,    10,    11,    12,    13,    14,    15,
    16,    17,    18,    19,    20,    21,    22,    23,    24,    25,
    26,    27,    28,    29,    30,    31,    32,    33,    34,    35,
    36,    37,    38,    39,    40,    41,    42,    43,    44,    45,
    46,    47,    48,    49,    50,    51,    52,    53,    54,    55,
    56,    57,    58,    59,    60,    61,    62,    63,    64,    65,
    66,    67
};

#if YYDEBUG != 0
static const short yyprhs[] = {     0,
     0,     1,     4,     7,    10,    12,    14,    18,    21,    25,
    29,    32,    36,    39,    42,    45,    48,    50,    52,    54,
    56,    58,    61,    65,    68,    72,    75,    78,    80,    82,
    90,    93,    97,   102,   108,   115,   123,   127,   130,   133,
   136,   139,   142,   145,   149,   153,   156,   162,   165,   170,
   176,   184,   192,   200,   203,   207,   212,   219,   227,   233,
   236,   241,   247,   257,   260,   265,   272,   281,   291,   299,
   302,   306,   311,   317,   324,   332,   334,   336,   338,   341,
   344,   349,   353,   355,   358,   359,   361,   363,   367,   369,
   371,   373,   375,   377,   382,   386,   391,   394,   397,   401,
   405,   409,   413,   417,   421,   425,   429,   433,   437,   441,
   445,   449,   453,   457,   461,   465,   469,   473,   477,   480,
   483,   488,   491,   496,   501,   506,   513,   517,   522,   529,
   530,   532,   540,   544,   549,   556,   564,   565,   567,   571,
   573,   575,   580,   584,   589,   593,   600,   606,   613,   617,
   618
};

static const short yyrhs[] = {    -1,
    68,    69,     0,    68,    70,     0,    68,    81,     0,     1,
     0,     7,     0,    33,    83,    36,     0,    33,     1,     0,
    33,    83,     1,     0,    12,     5,    71,     0,    12,     1,
     0,    12,     5,     1,     0,    11,     6,     0,    11,     1,
     0,    13,     5,     0,    13,     1,     0,    10,     0,     8,
     0,     9,     0,    15,     0,    14,     0,     1,    36,     0,
    40,    76,    41,     0,    40,     1,     0,    40,    76,     1,
     0,    79,    36,     0,    79,     1,     0,    70,     0,     7,
     0,    28,    38,     5,    34,    79,    39,    36,     0,    28,
     1,     0,    28,    38,     1,     0,    28,    38,     5,     1,
     0,    28,    38,     5,    34,     1,     0,    28,    38,     5,
    34,    79,     1,     0,    28,    38,     5,    34,    79,    39,
     1,     0,    23,    79,    36,     0,    23,    36,     0,    23,
     1,     0,    21,    36,     0,    21,     1,     0,    22,    36,
     0,    22,     1,     0,    33,    83,    36,     0,    33,    83,
     1,     0,    78,    36,     0,    16,    38,    77,    39,    71,
     0,    16,     1,     0,    16,    38,    77,     1,     0,    16,
    38,    77,    39,     1,     0,    16,    38,    77,    39,    71,
    17,    71,     0,    16,    38,    77,    39,    71,    17,     1,
     0,    19,    71,    18,    38,    77,    39,    36,     0,    19,
     1,     0,    19,    71,     1,     0,    19,    71,    18,     1,
     0,    19,    71,    18,    38,    77,     1,     0,    19,    71,
    18,    38,    77,    39,     1,     0,    18,    38,    77,    39,
    71,     0,    18,     1,     0,    18,    38,    77,     1,     0,
    18,    38,    77,    39,     1,     0,    20,    38,    77,    36,
    77,    36,    77,    39,    71,     0,    20,     1,     0,    20,
    38,    77,     1,     0,    20,    38,    77,    36,    77,     1,
     0,    20,    38,    77,    36,    77,    36,    77,     1,     0,
    20,    38,    77,    36,    77,    36,    77,    39,     1,     0,
    72,    38,    79,    39,    40,    73,    41,     0,    72,     1,
     0,    72,    38,     1,     0,    72,    38,    79,     1,     0,
    72,    38,    79,    39,     1,     0,    72,    38,    79,    39,
    40,     1,     0,    72,    38,    79,    39,    40,    73,     1,
     0,    24,     0,    27,     0,    74,     0,    73,    74,     0,
    73,    75,     0,    25,    79,    37,    71,     0,    26,    37,
    71,     0,    71,     0,    76,    71,     0,     0,    79,     0,
    78,     0,    83,    44,    79,     0,     3,     0,     6,     0,
     4,     0,    29,     0,     5,     0,     5,    42,    79,    43,
     0,     5,    42,     1,     0,     5,    42,    79,     1,     0,
     5,    63,     0,     5,    64,     0,    38,    79,    39,     0,
    38,    79,     1,     0,    79,    45,    79,     0,    79,    46,
    79,     0,    79,    58,    79,     0,    79,    59,    79,     0,
    79,    60,    79,     0,    79,    61,    79,     0,    79,    62,
    79,     0,    79,    49,    79,     0,    79,    47,    79,     0,
    79,    48,    79,     0,    79,    56,    79,     0,    79,    57,
    79,     0,    79,    52,    79,     0,    79,    53,    79,     0,
    79,    54,    79,     0,    79,    55,    79,     0,    79,    50,
    79,     0,    79,    51,    79,     0,    59,    79,     0,    66,
    79,     0,    30,    38,    82,    39,     0,    30,     1,     0,
    30,    38,    82,     1,     0,     5,    38,    82,    39,     0,
     5,    38,    82,     1,     0,     6,    67,     5,    38,    82,
    39,     0,     6,    67,     1,     0,     6,    67,     5,     1,
     0,     6,    67,     5,    38,    82,     1,     0,     0,    32,
     0,    80,    31,     5,    38,    84,    39,    71,     0,    80,
    31,     1,     0,    80,    31,     5,     1,     0,    80,    31,
     5,    38,    84,     1,     0,    80,    31,     5,    38,    84,
    39,     1,     0,     0,    79,     0,    82,    34,    79,     0,
    35,     0,     5,     0,     5,    42,    79,    43,     0,     5,
    42,     1,     0,     5,    42,    79,     1,     0,    83,    34,
     5,     0,    83,    34,     5,    42,    79,    43,     0,    83,
    34,     5,    42,     1,     0,    83,    34,     5,    42,    79,
     1,     0,    83,    34,    35,     0,     0,    83,     0
};

#endif

#if YYDEBUG != 0
static const short yyrline[] = { 0,
   123,   125,   126,   127,   128,   131,   133,   134,   135,   136,
   137,   138,   139,   140,   141,   142,   145,   147,   148,   149,
   150,   153,   155,   156,   157,   158,   159,   160,   161,   162,
   165,   166,   167,   168,   172,   176,   180,   181,   182,   183,
   184,   185,   186,   187,   188,   189,   190,   191,   192,   193,
   197,   200,   204,   207,   208,   212,   216,   220,   224,   227,
   228,   229,   233,   236,   237,   238,   242,   246,   250,   268,
   269,   270,   271,   272,   276,   282,   284,   287,   289,   290,
   293,   297,   301,   303,   306,   308,   309,   312,   323,   325,
   326,   327,   328,   329,   330,   331,   332,   333,   334,   335,
   336,   337,   338,   339,   340,   341,   342,   343,   344,   345,
   346,   347,   348,   349,   350,   351,   352,   353,   354,   355,
   356,   357,   358,   359,   360,   361,   362,   363,   364,   367,
   369,   372,   379,   380,   381,   382,   387,   389,   390,   393,
   395,   396,   397,   398,   399,   400,   403,   407,   411,   414,
   416
};

static const char * const yytname[] = {   "$","error","$undefined.","NUM","STR",
"IDENT","OBJ","COMMENT","IFDEF","IFNDEF","ECHODEF","INCLUDE","DEFINE","UNDEF",
"ENDIF","ELSEDEF","IF","ELSE","WHILE","DO","FOR","BREAK","CONTINUE","RETURN",
"SWITCH","CASE","DEFAULT","SWITCHALL","MAKEARRAY","TOP","PUSH","FUNC","PUBLIC",
"VAR","COMMA","BLANK","SEMICOLON","COLON","OPAREN","CPAREN","OBRACE","CBRACE",
"OBRACK","CBRACK","ASGN","OR","AND","BITOR","BITXOR","BITAND","EQ","NE","GT",
"GTE","LT","LTE","SHIFTR","SHIFTL","ADD","SUB","MUL","DIV","MOD","INCR","DECR",
"UNARY","NOT","CALL","program","global","directive","statement","switch","caselist",
"case","default","statements","cond","assign","expr","opt_pub","funcdef","arglist",
"vardecl","varlist",""
};
#endif

static const short yyr1[] = {     0,
    68,    68,    68,    68,    68,    69,    69,    69,    69,    69,
    69,    69,    69,    69,    69,    69,    70,    70,    70,    70,
    70,    71,    71,    71,    71,    71,    71,    71,    71,    71,
    71,    71,    71,    71,    71,    71,    71,    71,    71,    71,
    71,    71,    71,    71,    71,    71,    71,    71,    71,    71,
    71,    71,    71,    71,    71,    71,    71,    71,    71,    71,
    71,    71,    71,    71,    71,    71,    71,    71,    71,    71,
    71,    71,    71,    71,    71,    72,    72,    73,    73,    73,
    74,    75,    76,    76,    77,    77,    77,    78,    79,    79,
    79,    79,    79,    79,    79,    79,    79,    79,    79,    79,
    79,    79,    79,    79,    79,    79,    79,    79,    79,    79,
    79,    79,    79,    79,    79,    79,    79,    79,    79,    79,
    79,    79,    79,    79,    79,    79,    79,    79,    79,    80,
    80,    81,    81,    81,    81,    81,    82,    82,    82,    83,
    83,    83,    83,    83,    83,    83,    83,    83,    83,    84,
    84
};

static const short yyr2[] = {     0,
     0,     2,     2,     2,     1,     1,     3,     2,     3,     3,
     2,     3,     2,     2,     2,     2,     1,     1,     1,     1,
     1,     2,     3,     2,     3,     2,     2,     1,     1,     7,
     2,     3,     4,     5,     6,     7,     3,     2,     2,     2,
     2,     2,     2,     3,     3,     2,     5,     2,     4,     5,
     7,     7,     7,     2,     3,     4,     6,     7,     5,     2,
     4,     5,     9,     2,     4,     6,     8,     9,     7,     2,
     3,     4,     5,     6,     7,     1,     1,     1,     2,     2,
     4,     3,     1,     2,     0,     1,     1,     3,     1,     1,
     1,     1,     1,     4,     3,     4,     2,     2,     3,     3,
     3,     3,     3,     3,     3,     3,     3,     3,     3,     3,
     3,     3,     3,     3,     3,     3,     3,     3,     2,     2,
     4,     2,     4,     4,     4,     6,     3,     4,     6,     0,
     1,     7,     3,     4,     6,     7,     0,     1,     3,     1,
     1,     4,     3,     4,     3,     6,     5,     6,     3,     0,
     1
};

static const short yydefact[] = {     0,
     5,   130,     6,    18,    19,    17,     0,     0,     0,    21,
    20,   131,     0,     2,     3,     0,     4,    14,    13,    11,
     0,    16,    15,     8,   141,   140,     0,     0,    12,    89,
    91,    93,    90,    29,     0,     0,     0,     0,     0,     0,
     0,    76,    77,     0,    92,     0,     0,     0,     0,     0,
     0,    28,    10,     0,     0,     0,     0,     0,     9,     0,
     7,   133,     0,    22,   137,     0,    97,    98,     0,    48,
    85,    60,    85,    54,     0,    64,    85,    41,    40,    43,
    42,    39,    93,    38,     0,    31,     0,   122,   137,     0,
     0,    24,    83,     0,   119,   120,    70,     0,    46,    27,
    26,     0,     0,     0,     0,     0,     0,     0,     0,     0,
     0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
   143,     0,   145,   149,   134,   150,   138,     0,    95,     0,
   127,     0,     0,    87,    86,     0,    55,     0,     0,     0,
    37,    32,     0,     0,    45,    44,   100,    99,    25,    23,
    84,    71,     0,   101,   102,   109,   110,   108,   117,   118,
   113,   114,   115,   116,   111,   112,   103,   104,   105,   106,
   107,    88,   144,   142,     0,   151,     0,   125,     0,   124,
    96,    94,   128,   137,    49,     0,    61,     0,    56,    85,
    65,    85,    95,     0,    33,     0,   123,   121,    72,     0,
   147,     0,   135,     0,   139,     0,    50,    47,    62,    59,
     0,     0,    96,    94,    34,     0,    73,     0,   148,   146,
   136,   132,   129,   126,     0,    57,     0,    66,    85,    35,
     0,    74,     0,     0,    78,    52,    51,    58,    53,     0,
    36,    30,     0,    75,     0,    69,    79,    80,    67,     0,
     0,     0,    68,    63,     0,    81,    82,     0,     0
};

static const short yydefgoto[] = {     2,
    14,    52,    53,    54,   234,   235,   248,    94,   133,    55,
    56,    16,    17,   128,    57,   177
};

static const short yypact[] = {  1045,
-32768,   245,-32768,-32768,-32768,-32768,    92,   167,   182,-32768,
-32768,-32768,    15,-32768,-32768,    -1,-32768,-32768,-32768,-32768,
   266,-32768,-32768,-32768,     4,-32768,   142,   193,    56,-32768,
-32768,   598,   -19,-32768,    93,    94,   330,    98,   144,   146,
    82,-32768,-32768,   115,-32768,   122,    91,   104,   394,   104,
   104,-32768,-32768,   124,    61,   262,   -10,   100,-32768,   149,
-32768,-32768,   126,-32768,   104,   816,-32768,-32768,   233,-32768,
   880,-32768,   880,    56,    18,-32768,   880,-32768,-32768,-32768,
-32768,-32768,   133,-32768,   646,-32768,   261,-32768,   104,   145,
   919,    56,-32768,   202,-32768,-32768,-32768,   822,-32768,-32768,
-32768,   104,   104,   104,   104,   104,   104,   104,   104,   104,
   104,   104,   104,   104,   104,   104,   104,   104,   104,   104,
-32768,   326,    71,-32768,-32768,    91,   710,    20,    -2,   390,
-32768,   136,    21,-32768,   710,    42,-32768,   139,   154,   828,
-32768,-32768,    13,    22,-32768,-32768,-32768,-32768,    56,-32768,
-32768,-32768,   943,  1051,  1067,   958,  1081,  1094,  1105,  1105,
   891,   891,   891,   891,   188,   188,   -33,   -33,-32768,-32768,
-32768,   710,-32768,-32768,   866,    80,    43,-32768,   104,-32768,
     1,   151,-32768,   104,-32768,   458,-32768,   522,-32768,   880,
-32768,   880,-32768,   454,-32768,   897,-32768,-32768,-32768,    12,
-32768,   518,-32768,   586,   710,    50,    56,   169,    56,-32768,
    52,   156,-32768,-32768,-32768,   982,-32768,    16,-32768,-32768,
    56,-32768,-32768,-32768,   650,-32768,   164,-32768,   880,-32768,
   168,-32768,   104,    14,-32768,    56,-32768,-32768,-32768,    89,
-32768,-32768,  1034,-32768,    78,-32768,-32768,-32768,-32768,   714,
   778,   778,    56,-32768,    56,-32768,-32768,   173,-32768
};

static const short yypgoto[] = {-32768,
-32768,   189,   -37,-32768,-32768,   -35,-32768,-32768,   -71,   -68,
   -40,-32768,-32768,   -82,    -9,-32768
};


#define	YYLAST		1167


static const short yytable[] = {    75,
    85,   136,   134,    27,   134,   139,   144,    91,   134,    95,
    96,    93,   217,   195,   244,    24,   232,   122,   137,    25,
   178,   185,   197,    60,   127,   130,   117,   118,   119,    28,
   135,  -143,   135,   120,  -144,   138,   135,    90,   233,   245,
   233,  -143,   187,   203,  -144,    58,   196,    69,   127,    26,
   223,   218,   226,   179,   246,   179,   151,   153,   180,   186,
   198,   154,   155,   156,   157,   158,   159,   160,   161,   162,
   163,   164,   165,   166,   167,   168,   169,   170,   171,   172,
   188,   204,    82,   179,    30,    31,    83,    33,   224,   249,
   227,    64,    18,    70,    72,    25,    99,    19,    76,   194,
   121,   206,    30,    31,    83,    33,    30,    31,    83,    33,
    45,    46,   175,    60,   252,    86,   176,    84,   211,    48,
   212,   134,    88,   134,    97,    26,   125,   250,    45,    46,
    71,    73,    45,    46,   202,    77,   183,    48,   205,   189,
    50,    48,    59,   127,    78,   145,    80,    51,   208,   135,
   210,   135,    87,   123,   191,   216,   228,   240,    50,    89,
   134,    98,    50,   126,   238,    51,   222,    20,   241,    51,
    65,    21,   259,   184,   140,    60,   190,    61,    60,    79,
   146,    81,    22,   124,  -142,   225,    23,   237,   135,   192,
    15,   229,   243,    62,  -142,    67,    68,    63,   247,   239,
     0,     0,   149,   242,    30,    31,    32,    33,    34,     4,
     5,     6,   254,   256,   257,    10,    11,    35,     0,    36,
    37,    38,    39,    40,    41,    42,     0,     0,    43,    44,
    45,    46,     0,   131,    47,     0,    26,   132,     0,    48,
     0,    49,   150,     0,   258,   115,   116,   117,   118,   119,
     0,     3,     4,     5,     6,     7,     8,     9,    10,    11,
    50,   142,   100,     0,     0,   143,    29,    51,    30,    31,
    32,    33,    34,     4,     5,     6,    12,    13,     0,    10,
    11,    35,     0,    36,    37,    38,    39,    40,    41,    42,
     0,     0,    43,    44,    45,    46,     0,   101,    47,     0,
    26,     0,     0,    48,     0,    49,   102,   103,   104,   105,
   106,   107,   108,   109,   110,   111,   112,   113,   114,   115,
   116,   117,   118,   119,    50,     0,   173,     0,     0,     0,
    74,    51,    30,    31,    32,    33,    34,     4,     5,     6,
     0,     0,     0,    10,    11,    35,     0,    36,    37,    38,
    39,    40,    41,    42,     0,     0,    43,    44,    45,    46,
     0,     0,    47,     0,    26,     0,     0,    48,   174,    49,
   102,   103,   104,   105,   106,   107,   108,   109,   110,   111,
   112,   113,   114,   115,   116,   117,   118,   119,    50,     0,
   181,     0,     0,     0,    92,    51,    30,    31,    32,    33,
    34,     4,     5,     6,     0,     0,     0,    10,    11,    35,
     0,    36,    37,    38,    39,    40,    41,    42,     0,     0,
    43,    44,    45,    46,     0,     0,    47,     0,    26,     0,
     0,    48,   182,    49,   102,   103,   104,   105,   106,   107,
   108,   109,   110,   111,   112,   113,   114,   115,   116,   117,
   118,   119,    50,     0,   213,     0,     0,     0,   207,    51,
    30,    31,    32,    33,    34,     4,     5,     6,     0,     0,
     0,    10,    11,    35,     0,    36,    37,    38,    39,    40,
    41,    42,     0,     0,    43,    44,    45,    46,     0,     0,
    47,     0,    26,     0,     0,    48,   214,    49,   102,   103,
   104,   105,   106,   107,   108,   109,   110,   111,   112,   113,
   114,   115,   116,   117,   118,   119,    50,     0,   219,     0,
     0,     0,   209,    51,    30,    31,    32,    33,    34,     4,
     5,     6,     0,     0,     0,    10,    11,    35,     0,    36,
    37,    38,    39,    40,    41,    42,     0,     0,    43,    44,
    45,    46,     0,     0,    47,     0,    26,     0,     0,    48,
   220,    49,   102,   103,   104,   105,   106,   107,   108,   109,
   110,   111,   112,   113,   114,   115,   116,   117,   118,   119,
    50,     0,     0,     0,     0,     0,   221,    51,    30,    31,
    32,    33,    34,     4,     5,     6,     0,     0,     0,    10,
    11,    35,     0,    36,    37,    38,    39,    40,    41,    42,
     0,     0,    43,    44,    45,    46,     0,     0,    47,     0,
    26,     0,     0,    48,     0,    49,     0,     0,     0,     0,
     0,  -141,     0,     0,     0,    65,     0,     0,     0,    66,
     0,  -141,     0,     0,    50,     0,     0,     0,     0,     0,
   236,    51,    30,    31,    32,    33,    34,     4,     5,     6,
    67,    68,     0,    10,    11,    35,     0,    36,    37,    38,
    39,    40,    41,    42,     0,     0,    43,    44,    45,    46,
     0,   141,    47,     0,    26,     0,     0,    48,     0,    49,
   102,   103,   104,   105,   106,   107,   108,   109,   110,   111,
   112,   113,   114,   115,   116,   117,   118,   119,    50,     0,
     0,     0,     0,     0,   253,    51,    30,    31,    32,    33,
    34,     4,     5,     6,     0,     0,     0,    10,    11,    35,
     0,    36,    37,    38,    39,    40,    41,    42,     0,     0,
    43,    44,    45,    46,     0,     0,    47,     0,    26,     0,
     0,    48,     0,    49,   102,   103,   104,   105,   106,   107,
   108,   109,   110,   111,   112,   113,   114,   115,   116,   117,
   118,   119,    50,     0,     0,     0,     0,     0,   255,    51,
    30,    31,    32,    33,    34,     4,     5,     6,     0,     0,
     0,    10,    11,    35,     0,    36,    37,    38,    39,    40,
    41,    42,     0,     0,    43,    44,    45,    46,     0,     0,
    47,     0,    26,     0,     0,    48,   129,    49,    30,    31,
    83,    33,   152,     0,    30,    31,    83,    33,   193,     0,
    30,    31,    83,    33,     0,     0,    50,     0,     0,     0,
     0,     0,     0,    51,    45,    46,     0,     0,     0,     0,
    45,    46,     0,    48,     0,     0,    45,    46,     0,    48,
     0,     0,     0,     0,     0,    48,   201,     0,    30,    31,
    83,    33,     0,     0,    50,     0,     0,     0,     0,     0,
    50,    51,    30,    31,    32,    33,    50,    51,     0,     0,
     0,     0,     0,    51,    45,    46,     0,   215,     0,    30,
    31,    83,    33,    48,     0,     0,     0,     0,    45,    46,
     0,     0,     0,     0,    26,     0,     0,    48,     0,   147,
     0,     0,     0,     0,    50,    45,    46,     0,     0,     0,
     0,    51,     0,     0,    48,     0,     0,     0,    50,     0,
     0,     0,     0,   199,     0,    51,   113,   114,   115,   116,
   117,   118,   119,     0,     0,    50,     0,   148,     0,     0,
     0,     0,    51,   102,   103,   104,   105,   106,   107,   108,
   109,   110,   111,   112,   113,   114,   115,   116,   117,   118,
   119,   200,   230,     0,     0,     0,     0,   102,   103,   104,
   105,   106,   107,   108,   109,   110,   111,   112,   113,   114,
   115,   116,   117,   118,   119,   105,   106,   107,   108,   109,
   110,   111,   112,   113,   114,   115,   116,   117,   118,   119,
   231,     0,     0,     0,     0,     0,   102,   103,   104,   105,
   106,   107,   108,   109,   110,   111,   112,   113,   114,   115,
   116,   117,   118,   119,    -1,     1,     0,     0,     0,     0,
     0,    -1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,
     0,     0,     0,     0,     0,     0,     0,     0,     0,     0,
   251,     0,     0,     0,     0,    -1,    -1,    -1,   102,   103,
   104,   105,   106,   107,   108,   109,   110,   111,   112,   113,
   114,   115,   116,   117,   118,   119,   103,   104,   105,   106,
   107,   108,   109,   110,   111,   112,   113,   114,   115,   116,
   117,   118,   119,   104,   105,   106,   107,   108,   109,   110,
   111,   112,   113,   114,   115,   116,   117,   118,   119,   106,
   107,   108,   109,   110,   111,   112,   113,   114,   115,   116,
   117,   118,   119,   107,   108,   109,   110,   111,   112,   113,
   114,   115,   116,   117,   118,   119,   109,   110,   111,   112,
   113,   114,   115,   116,   117,   118,   119
};

static const short yycheck[] = {    37,
    41,    73,    71,    13,    73,    77,    89,    48,    77,    50,
    51,    49,     1,     1,     1,     1,     1,    58,     1,     5,
     1,     1,     1,    34,    65,    66,    60,    61,    62,    31,
    71,    34,    73,    44,    34,    18,    77,    47,    25,    26,
    25,    44,     1,     1,    44,    42,    34,    67,    89,    35,
     1,    40,     1,    34,    41,    34,    94,    98,    39,    39,
    39,   102,   103,   104,   105,   106,   107,   108,   109,   110,
   111,   112,   113,   114,   115,   116,   117,   118,   119,   120,
    39,    39,     1,    34,     3,     4,     5,     6,    39,     1,
    39,    36,     1,     1,     1,     5,    36,     6,     1,   140,
     1,   184,     3,     4,     5,     6,     3,     4,     5,     6,
    29,    30,    42,    34,    37,     1,   126,    36,   190,    38,
   192,   190,     1,   192,     1,    35,     1,    39,    29,    30,
    38,    38,    29,    30,   175,    38,     1,    38,   179,     1,
    59,    38,     1,   184,     1,     1,     1,    66,   186,   190,
   188,   192,    38,     5,     1,   196,     1,   229,    59,    38,
   229,    38,    59,    38,     1,    66,   204,     1,     1,    66,
    38,     5,     0,    38,    42,    34,    38,    36,    34,    36,
    36,    36,     1,    35,    34,    17,     5,   225,   229,    36,
     2,    36,   233,     1,    44,    63,    64,     5,   234,    36,
    -1,    -1,     1,    36,     3,     4,     5,     6,     7,     8,
     9,    10,   250,   251,   252,    14,    15,    16,    -1,    18,
    19,    20,    21,    22,    23,    24,    -1,    -1,    27,    28,
    29,    30,    -1,     1,    33,    -1,    35,     5,    -1,    38,
    -1,    40,    41,    -1,     0,    58,    59,    60,    61,    62,
    -1,     7,     8,     9,    10,    11,    12,    13,    14,    15,
    59,     1,     1,    -1,    -1,     5,     1,    66,     3,     4,
     5,     6,     7,     8,     9,    10,    32,    33,    -1,    14,
    15,    16,    -1,    18,    19,    20,    21,    22,    23,    24,
    -1,    -1,    27,    28,    29,    30,    -1,    36,    33,    -1,
    35,    -1,    -1,    38,    -1,    40,    45,    46,    47,    48,
    49,    50,    51,    52,    53,    54,    55,    56,    57,    58,
    59,    60,    61,    62,    59,    -1,     1,    -1,    -1,    -1,
     1,    66,     3,     4,     5,     6,     7,     8,     9,    10,
    -1,    -1,    -1,    14,    15,    16,    -1,    18,    19,    20,
    21,    22,    23,    24,    -1,    -1,    27,    28,    29,    30,
    -1,    -1,    33,    -1,    35,    -1,    -1,    38,    43,    40,
    45,    46,    47,    48,    49,    50,    51,    52,    53,    54,
    55,    56,    57,    58,    59,    60,    61,    62,    59,    -1,
     1,    -1,    -1,    -1,     1,    66,     3,     4,     5,     6,
     7,     8,     9,    10,    -1,    -1,    -1,    14,    15,    16,
    -1,    18,    19,    20,    21,    22,    23,    24,    -1,    -1,
    27,    28,    29,    30,    -1,    -1,    33,    -1,    35,    -1,
    -1,    38,    43,    40,    45,    46,    47,    48,    49,    50,
    51,    52,    53,    54,    55,    56,    57,    58,    59,    60,
    61,    62,    59,    -1,     1,    -1,    -1,    -1,     1,    66,
     3,     4,     5,     6,     7,     8,     9,    10,    -1,    -1,
    -1,    14,    15,    16,    -1,    18,    19,    20,    21,    22,
    23,    24,    -1,    -1,    27,    28,    29,    30,    -1,    -1,
    33,    -1,    35,    -1,    -1,    38,    43,    40,    45,    46,
    47,    48,    49,    50,    51,    52,    53,    54,    55,    56,
    57,    58,    59,    60,    61,    62,    59,    -1,     1,    -1,
    -1,    -1,     1,    66,     3,     4,     5,     6,     7,     8,
     9,    10,    -1,    -1,    -1,    14,    15,    16,    -1,    18,
    19,    20,    21,    22,    23,    24,    -1,    -1,    27,    28,
    29,    30,    -1,    -1,    33,    -1,    35,    -1,    -1,    38,
    43,    40,    45,    46,    47,    48,    49,    50,    51,    52,
    53,    54,    55,    56,    57,    58,    59,    60,    61,    62,
    59,    -1,    -1,    -1,    -1,    -1,     1,    66,     3,     4,
     5,     6,     7,     8,     9,    10,    -1,    -1,    -1,    14,
    15,    16,    -1,    18,    19,    20,    21,    22,    23,    24,
    -1,    -1,    27,    28,    29,    30,    -1,    -1,    33,    -1,
    35,    -1,    -1,    38,    -1,    40,    -1,    -1,    -1,    -1,
    -1,    34,    -1,    -1,    -1,    38,    -1,    -1,    -1,    42,
    -1,    44,    -1,    -1,    59,    -1,    -1,    -1,    -1,    -1,
     1,    66,     3,     4,     5,     6,     7,     8,     9,    10,
    63,    64,    -1,    14,    15,    16,    -1,    18,    19,    20,
    21,    22,    23,    24,    -1,    -1,    27,    28,    29,    30,
    -1,    36,    33,    -1,    35,    -1,    -1,    38,    -1,    40,
    45,    46,    47,    48,    49,    50,    51,    52,    53,    54,
    55,    56,    57,    58,    59,    60,    61,    62,    59,    -1,
    -1,    -1,    -1,    -1,     1,    66,     3,     4,     5,     6,
     7,     8,     9,    10,    -1,    -1,    -1,    14,    15,    16,
    -1,    18,    19,    20,    21,    22,    23,    24,    -1,    -1,
    27,    28,    29,    30,    -1,    -1,    33,    -1,    35,    -1,
    -1,    38,    -1,    40,    45,    46,    47,    48,    49,    50,
    51,    52,    53,    54,    55,    56,    57,    58,    59,    60,
    61,    62,    59,    -1,    -1,    -1,    -1,    -1,     1,    66,
     3,     4,     5,     6,     7,     8,     9,    10,    -1,    -1,
    -1,    14,    15,    16,    -1,    18,    19,    20,    21,    22,
    23,    24,    -1,    -1,    27,    28,    29,    30,    -1,    -1,
    33,    -1,    35,    -1,    -1,    38,     1,    40,     3,     4,
     5,     6,     1,    -1,     3,     4,     5,     6,     1,    -1,
     3,     4,     5,     6,    -1,    -1,    59,    -1,    -1,    -1,
    -1,    -1,    -1,    66,    29,    30,    -1,    -1,    -1,    -1,
    29,    30,    -1,    38,    -1,    -1,    29,    30,    -1,    38,
    -1,    -1,    -1,    -1,    -1,    38,     1,    -1,     3,     4,
     5,     6,    -1,    -1,    59,    -1,    -1,    -1,    -1,    -1,
    59,    66,     3,     4,     5,     6,    59,    66,    -1,    -1,
    -1,    -1,    -1,    66,    29,    30,    -1,     1,    -1,     3,
     4,     5,     6,    38,    -1,    -1,    -1,    -1,    29,    30,
    -1,    -1,    -1,    -1,    35,    -1,    -1,    38,    -1,     1,
    -1,    -1,    -1,    -1,    59,    29,    30,    -1,    -1,    -1,
    -1,    66,    -1,    -1,    38,    -1,    -1,    -1,    59,    -1,
    -1,    -1,    -1,     1,    -1,    66,    56,    57,    58,    59,
    60,    61,    62,    -1,    -1,    59,    -1,    39,    -1,    -1,
    -1,    -1,    66,    45,    46,    47,    48,    49,    50,    51,
    52,    53,    54,    55,    56,    57,    58,    59,    60,    61,
    62,    39,     1,    -1,    -1,    -1,    -1,    45,    46,    47,
    48,    49,    50,    51,    52,    53,    54,    55,    56,    57,
    58,    59,    60,    61,    62,    48,    49,    50,    51,    52,
    53,    54,    55,    56,    57,    58,    59,    60,    61,    62,
    39,    -1,    -1,    -1,    -1,    -1,    45,    46,    47,    48,
    49,    50,    51,    52,    53,    54,    55,    56,    57,    58,
    59,    60,    61,    62,     0,     1,    -1,    -1,    -1,    -1,
    -1,     7,     8,     9,    10,    11,    12,    13,    14,    15,
    -1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,    -1,
    37,    -1,    -1,    -1,    -1,    31,    32,    33,    45,    46,
    47,    48,    49,    50,    51,    52,    53,    54,    55,    56,
    57,    58,    59,    60,    61,    62,    46,    47,    48,    49,
    50,    51,    52,    53,    54,    55,    56,    57,    58,    59,
    60,    61,    62,    47,    48,    49,    50,    51,    52,    53,
    54,    55,    56,    57,    58,    59,    60,    61,    62,    49,
    50,    51,    52,    53,    54,    55,    56,    57,    58,    59,
    60,    61,    62,    50,    51,    52,    53,    54,    55,    56,
    57,    58,    59,    60,    61,    62,    52,    53,    54,    55,
    56,    57,    58,    59,    60,    61,    62
};
/* -*-C-*-  Note some compilers choke on comments on `#line' lines.  */
#line 3 "/usr/lib/bison.simple"

/* Skeleton output parser for bison,
   Copyright (C) 1984, 1989, 1990 Free Software Foundation, Inc.

   This program is free software; you can redistribute it and/or modify
   it under the terms of the GNU General Public License as published by
   the Free Software Foundation; either version 2, or (at your option)
   any later version.

   This program is distributed in the hope that it will be useful,
   but WITHOUT ANY WARRANTY; without even the implied warranty of
   MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
   GNU General Public License for more details.

   You should have received a copy of the GNU General Public License
   along with this program; if not, write to the Free Software
   Foundation, Inc., 675 Mass Ave, Cambridge, MA 02139, USA.  */

/* As a special exception, when this file is copied by Bison into a
   Bison output file, you may use that output file without restriction.
   This special exception was added by the Free Software Foundation
   in version 1.24 of Bison.  */

#ifndef alloca
#ifdef __GNUC__
#define alloca __builtin_alloca
#else /* not GNU C.  */
#if (!defined (__STDC__) && defined (sparc)) || defined (__sparc__) || defined (__sparc) || defined (__sgi)
#include <alloca.h>
#else /* not sparc */
#if defined (MSDOS) && !defined (__TURBOC__)
#include <malloc.h>
#else /* not MSDOS, or __TURBOC__ */
#if defined(_AIX)
#include <malloc.h>
 #pragma alloca
#else /* not MSDOS, __TURBOC__, or _AIX */
#ifdef __hpux
#ifdef __cplusplus
extern "C" {
void *alloca (unsigned int);
};
#else /* not __cplusplus */
void *alloca ();
#endif /* not __cplusplus */
#endif /* __hpux */
#endif /* not _AIX */
#endif /* not MSDOS, or __TURBOC__ */
#endif /* not sparc.  */
#endif /* not GNU C.  */
#endif /* alloca not defined.  */

/* This is the parser code that is written into each bison parser
  when the %semantic_parser declaration is not specified in the grammar.
  It was written by Richard Stallman by simplifying the hairy parser
  used when %semantic_parser is specified.  */

/* Note: there must be only one dollar sign in this file.
   It is replaced by the list of actions, each action
   as one case of the switch.  */

#define yyerrok		(yyerrstatus = 0)
#define yyclearin	(yychar = YYEMPTY)
#define YYEMPTY		-2
#define YYEOF		0
#define YYACCEPT	return(0)
#define YYABORT 	return(1)
#define YYERROR		goto yyerrlab1
/* Like YYERROR except do call yyerror.
   This remains here temporarily to ease the
   transition to the new meaning of YYERROR, for GCC.
   Once GCC version 2 has supplanted version 1, this can go.  */
#define YYFAIL		goto yyerrlab
#define YYRECOVERING()  (!!yyerrstatus)
#define YYBACKUP(token, value) \
do								\
  if (yychar == YYEMPTY && yylen == 1)				\
    { yychar = (token), yylval = (value);			\
      yychar1 = YYTRANSLATE (yychar);				\
      YYPOPSTACK;						\
      goto yybackup;						\
    }								\
  else								\
    { yyerror ("syntax error: cannot back up"); YYERROR; }	\
while (0)

#define YYTERROR	1
#define YYERRCODE	256

#ifndef YYPURE
#define YYLEX		yylex()
#endif

#ifdef YYPURE
#ifdef YYLSP_NEEDED
#ifdef YYLEX_PARAM
#define YYLEX		yylex(&yylval, &yylloc, YYLEX_PARAM)
#else
#define YYLEX		yylex(&yylval, &yylloc)
#endif
#else /* not YYLSP_NEEDED */
#ifdef YYLEX_PARAM
#define YYLEX		yylex(&yylval, YYLEX_PARAM)
#else
#define YYLEX		yylex(&yylval)
#endif
#endif /* not YYLSP_NEEDED */
#endif

/* If nonreentrant, generate the variables here */

#ifndef YYPURE

int	yychar;			/*  the lookahead symbol		*/
YYSTYPE	yylval;			/*  the semantic value of the		*/
				/*  lookahead symbol			*/

#ifdef YYLSP_NEEDED
YYLTYPE yylloc;			/*  location data for the lookahead	*/
				/*  symbol				*/
#endif

int yynerrs;			/*  number of parse errors so far       */
#endif  /* not YYPURE */

#if YYDEBUG != 0
int yydebug;			/*  nonzero means print parse trace	*/
/* Since this is uninitialized, it does not stop multiple parsers
   from coexisting.  */
#endif

/*  YYINITDEPTH indicates the initial size of the parser's stacks	*/

#ifndef	YYINITDEPTH
#define YYINITDEPTH 200
#endif

/*  YYMAXDEPTH is the maximum size the stacks can grow to
    (effective only if the built-in stack extension method is used).  */

#if YYMAXDEPTH == 0
#undef YYMAXDEPTH
#endif

#ifndef YYMAXDEPTH
#define YYMAXDEPTH 10000
#endif

/* Prevent warning if -Wstrict-prototypes.  */
#ifdef __GNUC__
int yyparse (void);
#endif

#if __GNUC__ > 1		/* GNU C and GNU C++ define this.  */
#define __yy_memcpy(FROM,TO,COUNT)	__builtin_memcpy(TO,FROM,COUNT)
#else				/* not GNU C or C++ */
#ifndef __cplusplus

/* This is the most reliable way to avoid incompatibilities
   in available built-in functions on various systems.  */
static void
__yy_memcpy (from, to, count)
     char *from;
     char *to;
     int count;
{
  register char *f = from;
  register char *t = to;
  register int i = count;

  while (i-- > 0)
    *t++ = *f++;
}

#else /* __cplusplus */

/* This is the most reliable way to avoid incompatibilities
   in available built-in functions on various systems.  */
static void
__yy_memcpy (char *from, char *to, int count)
{
  register char *f = from;
  register char *t = to;
  register int i = count;

  while (i-- > 0)
    *t++ = *f++;
}

#endif
#endif

#line 192 "/usr/lib/bison.simple"

/* The user can define YYPARSE_PARAM as the name of an argument to be passed
   into yyparse.  The argument should have type void *.
   It should actually point to an object.
   Grammar actions can access the variable by casting it
   to the proper pointer type.  */

#ifdef YYPARSE_PARAM
#define YYPARSE_PARAM_DECL void *YYPARSE_PARAM;
#else
#define YYPARSE_PARAM
#define YYPARSE_PARAM_DECL
#endif

int
yyparse(YYPARSE_PARAM)
     YYPARSE_PARAM_DECL
{
  register int yystate;
  register int yyn;
  register short *yyssp;
  register YYSTYPE *yyvsp;
  int yyerrstatus;	/*  number of tokens to shift before error messages enabled */
  int yychar1 = 0;		/*  lookahead token as an internal (translated) token number */

  short	yyssa[YYINITDEPTH];	/*  the state stack			*/
  YYSTYPE yyvsa[YYINITDEPTH];	/*  the semantic value stack		*/

  short *yyss = yyssa;		/*  refer to the stacks thru separate pointers */
  YYSTYPE *yyvs = yyvsa;	/*  to allow yyoverflow to reallocate them elsewhere */

#ifdef YYLSP_NEEDED
  YYLTYPE yylsa[YYINITDEPTH];	/*  the location stack			*/
  YYLTYPE *yyls = yylsa;
  YYLTYPE *yylsp;

#define YYPOPSTACK   (yyvsp--, yyssp--, yylsp--)
#else
#define YYPOPSTACK   (yyvsp--, yyssp--)
#endif

  int yystacksize = YYINITDEPTH;

#ifdef YYPURE
  int yychar;
  YYSTYPE yylval;
  int yynerrs;
#ifdef YYLSP_NEEDED
  YYLTYPE yylloc;
#endif
#endif

  YYSTYPE yyval;		/*  the variable used to return		*/
				/*  semantic values from the action	*/
				/*  routines				*/

  int yylen;

#if YYDEBUG != 0
  if (yydebug)
    fprintf(stderr, "Starting parse\n");
#endif

  yystate = 0;
  yyerrstatus = 0;
  yynerrs = 0;
  yychar = YYEMPTY;		/* Cause a token to be read.  */

  /* Initialize stack pointers.
     Waste one element of value and location stack
     so that they stay on the same level as the state stack.
     The wasted elements are never initialized.  */

  yyssp = yyss - 1;
  yyvsp = yyvs;
#ifdef YYLSP_NEEDED
  yylsp = yyls;
#endif

/* Push a new state, which is found in  yystate  .  */
/* In all cases, when you get here, the value and location stacks
   have just been pushed. so pushing a state here evens the stacks.  */
yynewstate:

  *++yyssp = yystate;

  if (yyssp >= yyss + yystacksize - 1)
    {
      /* Give user a chance to reallocate the stack */
      /* Use copies of these so that the &'s don't force the real ones into memory. */
      YYSTYPE *yyvs1 = yyvs;
      short *yyss1 = yyss;
#ifdef YYLSP_NEEDED
      YYLTYPE *yyls1 = yyls;
#endif

      /* Get the current used size of the three stacks, in elements.  */
      int size = yyssp - yyss + 1;

#ifdef yyoverflow
      /* Each stack pointer address is followed by the size of
	 the data in use in that stack, in bytes.  */
#ifdef YYLSP_NEEDED
      /* This used to be a conditional around just the two extra args,
	 but that might be undefined if yyoverflow is a macro.  */
      yyoverflow("parser stack overflow",
		 &yyss1, size * sizeof (*yyssp),
		 &yyvs1, size * sizeof (*yyvsp),
		 &yyls1, size * sizeof (*yylsp),
		 &yystacksize);
#else
      yyoverflow("parser stack overflow",
		 &yyss1, size * sizeof (*yyssp),
		 &yyvs1, size * sizeof (*yyvsp),
		 &yystacksize);
#endif

      yyss = yyss1; yyvs = yyvs1;
#ifdef YYLSP_NEEDED
      yyls = yyls1;
#endif
#else /* no yyoverflow */
      /* Extend the stack our own way.  */
      if (yystacksize >= YYMAXDEPTH)
	{
	  yyerror("parser stack overflow");
	  return 2;
	}
      yystacksize *= 2;
      if (yystacksize > YYMAXDEPTH)
	yystacksize = YYMAXDEPTH;
      yyss = (short *) alloca (yystacksize * sizeof (*yyssp));
      __yy_memcpy ((char *)yyss1, (char *)yyss, size * sizeof (*yyssp));
      yyvs = (YYSTYPE *) alloca (yystacksize * sizeof (*yyvsp));
      __yy_memcpy ((char *)yyvs1, (char *)yyvs, size * sizeof (*yyvsp));
#ifdef YYLSP_NEEDED
      yyls = (YYLTYPE *) alloca (yystacksize * sizeof (*yylsp));
      __yy_memcpy ((char *)yyls1, (char *)yyls, size * sizeof (*yylsp));
#endif
#endif /* no yyoverflow */

      yyssp = yyss + size - 1;
      yyvsp = yyvs + size - 1;
#ifdef YYLSP_NEEDED
      yylsp = yyls + size - 1;
#endif

#if YYDEBUG != 0
      if (yydebug)
	fprintf(stderr, "Stack size increased to %d\n", yystacksize);
#endif

      if (yyssp >= yyss + yystacksize - 1)
	YYABORT;
    }

#if YYDEBUG != 0
  if (yydebug)
    fprintf(stderr, "Entering state %d\n", yystate);
#endif

  goto yybackup;
 yybackup:

/* Do appropriate processing given the current state.  */
/* Read a lookahead token if we need one and don't already have one.  */
/* yyresume: */

  /* First try to decide what to do without reference to lookahead token.  */

  yyn = yypact[yystate];
  if (yyn == YYFLAG)
    goto yydefault;

  /* Not known => get a lookahead token if don't already have one.  */

  /* yychar is either YYEMPTY or YYEOF
     or a valid token in external form.  */

  if (yychar == YYEMPTY)
    {
#if YYDEBUG != 0
      if (yydebug)
	fprintf(stderr, "Reading a token: ");
#endif
      yychar = YYLEX;
    }

  /* Convert token to internal form (in yychar1) for indexing tables with */

  if (yychar <= 0)		/* This means end of input. */
    {
      yychar1 = 0;
      yychar = YYEOF;		/* Don't call YYLEX any more */

#if YYDEBUG != 0
      if (yydebug)
	fprintf(stderr, "Now at end of input.\n");
#endif
    }
  else
    {
      yychar1 = YYTRANSLATE(yychar);

#if YYDEBUG != 0
      if (yydebug)
	{
	  fprintf (stderr, "Next token is %d (%s", yychar, yytname[yychar1]);
	  /* Give the individual parser a way to print the precise meaning
	     of a token, for further debugging info.  */
#ifdef YYPRINT
	  YYPRINT (stderr, yychar, yylval);
#endif
	  fprintf (stderr, ")\n");
	}
#endif
    }

  yyn += yychar1;
  if (yyn < 0 || yyn > YYLAST || yycheck[yyn] != yychar1)
    goto yydefault;

  yyn = yytable[yyn];

  /* yyn is what to do for this token type in this state.
     Negative => reduce, -yyn is rule number.
     Positive => shift, yyn is new state.
       New state is final state => don't bother to shift,
       just return success.
     0, or most negative number => error.  */

  if (yyn < 0)
    {
      if (yyn == YYFLAG)
	goto yyerrlab;
      yyn = -yyn;
      goto yyreduce;
    }
  else if (yyn == 0)
    goto yyerrlab;

  if (yyn == YYFINAL)
    YYACCEPT;

  /* Shift the lookahead token.  */

#if YYDEBUG != 0
  if (yydebug)
    fprintf(stderr, "Shifting token %d (%s), ", yychar, yytname[yychar1]);
#endif

  /* Discard the token being shifted unless it is eof.  */
  if (yychar != YYEOF)
    yychar = YYEMPTY;

  *++yyvsp = yylval;
#ifdef YYLSP_NEEDED
  *++yylsp = yylloc;
#endif

  /* count tokens shifted since error; after three, turn off error status.  */
  if (yyerrstatus) yyerrstatus--;

  yystate = yyn;
  goto yynewstate;

/* Do the default action for the current state.  */
yydefault:

  yyn = yydefact[yystate];
  if (yyn == 0)
    goto yyerrlab;

/* Do a reduction.  yyn is the number of a rule to reduce with.  */
yyreduce:
  yylen = yyr2[yyn];
  if (yylen > 0)
    yyval = yyvsp[1-yylen]; /* implement default value of the action */

#if YYDEBUG != 0
  if (yydebug)
    {
      int i;

      fprintf (stderr, "Reducing via rule %d (line %d), ",
	       yyn, yyrline[yyn]);

      /* Print the symbols being reduced, and their result.  */
      for (i = yyprhs[yyn]; yyrhs[i] > 0; i++)
	fprintf (stderr, "%s ", yytname[yyrhs[i]]);
      fprintf (stderr, " -> %s\n", yytname[yyr1[yyn]]);
    }
#endif


  switch (yyn) {

case 1:
#line 124 "mcpparse.y"
{ yyval.val = 0; ;
    break;}
case 2:
#line 125 "mcpparse.y"
{ yyval.val = 0; ;
    break;}
case 3:
#line 126 "mcpparse.y"
{ insertDirective(yyvsp[0].dir); yyval.val = 0; ;
    break;}
case 4:
#line 127 "mcpparse.y"
{ yyval.val = 0; ;
    break;}
case 5:
#line 128 "mcpparse.y"
{ yyerror("top level parse error"); yyerrok; yyclearin; yyval.val = 0; ;
    break;}
case 6:
#line 132 "mcpparse.y"
{ insertComment(yyvsp[0].string); yyval.val = 0; ;
    break;}
case 7:
#line 133 "mcpparse.y"
{ insertVar(PIECE_VAR, yyvsp[-1].ilist); yyval.val = 0; ;
    break;}
case 8:
#line 134 "mcpparse.y"
{ yyerror("invalid var declaration"); yyval.val = 0;  ;
    break;}
case 9:
#line 135 "mcpparse.y"
{ yyerror("missing ;"); yyval.val = 0; ;
    break;}
case 10:
#line 136 "mcpparse.y"
{ insertDefine(yyvsp[-1].string, yyvsp[0].stmt); yyval.val = 0; ;
    break;}
case 11:
#line 137 "mcpparse.y"
{ yyerror("expected identifier"); yyval.val = 0; ;
    break;}
case 12:
#line 138 "mcpparse.y"
{ yyerror("bogus statement"); yyval.val = 0; ;
    break;}
case 13:
#line 139 "mcpparse.y"
{ insertDirective(makeDirective(DIR_INCLUDE, yyvsp[0].string)); yyval.val = 0; ;
    break;}
case 14:
#line 140 "mcpparse.y"
{ yyerror("expected an object"); yyval.val = 0; ;
    break;}
case 15:
#line 141 "mcpparse.y"
{ insertDirective(makeDirective(DIR_UNDEF, yyvsp[0].string)); yyval.val = 0; ;
    break;}
case 16:
#line 142 "mcpparse.y"
{ yyerror("expected an identifier"); yyval.val = 0; ;
    break;}
case 17:
#line 146 "mcpparse.y"
{ yyval.dir = makeDirective(DIR_ECHO, yyvsp[0].string); ;
    break;}
case 18:
#line 147 "mcpparse.y"
{ yyval.dir = makeDirective(DIR_IFDEF, yyvsp[0].string); ;
    break;}
case 19:
#line 148 "mcpparse.y"
{ yyval.dir = makeDirective(DIR_IFNDEF, yyvsp[0].string); ;
    break;}
case 20:
#line 149 "mcpparse.y"
{ yyval.dir = makeDirective(DIR_ELSEDEF, NULL); ;
    break;}
case 21:
#line 150 "mcpparse.y"
{ yyval.dir = makeDirective(DIR_ENDIF, NULL); ;
    break;}
case 22:
#line 154 "mcpparse.y"
{ yyerror("invalid statement"); yyval.stmt = makeNull(); ;
    break;}
case 23:
#line 155 "mcpparse.y"
{ yyval.stmt = yyvsp[-1].stmt; ;
    break;}
case 24:
#line 156 "mcpparse.y"
{ yyerror("bogus statement"); yyval.stmt = makeNull(); ;
    break;}
case 25:
#line 157 "mcpparse.y"
{ yyerror("missing }"); yyval.stmt = makeNull(); ;
    break;}
case 26:
#line 158 "mcpparse.y"
{ yyval.stmt = makeStatement(STMT_EXPR, yyvsp[-1].expr); ;
    break;}
case 27:
#line 159 "mcpparse.y"
{ yyerror("missing ;"); yyval.stmt = makeNull(); ;
    break;}
case 28:
#line 160 "mcpparse.y"
{ yyval.stmt = makeDirectiveStatement(yyvsp[0].dir); ;
    break;}
case 29:
#line 161 "mcpparse.y"
{ yyval.stmt = makeComment(yyvsp[0].string); ;
    break;}
case 30:
#line 162 "mcpparse.y"
{
          yyval.stmt = makeArrayDecl(yyvsp[-4].string, yyvsp[-2].expr);
      ;
    break;}
case 31:
#line 165 "mcpparse.y"
{ yyerror("missing ("); yyval.stmt = makeNull(); ;
    break;}
case 32:
#line 166 "mcpparse.y"
{ yyerror("missing ident"); yyval.stmt = makeNull(); ;
    break;}
case 33:
#line 167 "mcpparse.y"
{ yyerror("missing ,"); yyval.stmt = makeNull(); ;
    break;}
case 34:
#line 168 "mcpparse.y"
{
          yyerror("missing expr");
          yyval.stmt = makeNull();
      ;
    break;}
case 35:
#line 172 "mcpparse.y"
{
          yyerror("missing )");
          yyval.stmt = makeNull();
      ;
    break;}
case 36:
#line 176 "mcpparse.y"
{
          yyerror("missing ;");
          yyval.stmt = makeNull();
      ;
    break;}
case 37:
#line 180 "mcpparse.y"
{ yyval.stmt = makeStatement(STMT_RETURN, yyvsp[-1].expr); ;
    break;}
case 38:
#line 181 "mcpparse.y"
{ yyval.stmt = makeStatement(STMT_RETURN, NULL); ;
    break;}
case 39:
#line 182 "mcpparse.y"
{ yyerror("missing ;"); yyval.stmt = makeNull(); ;
    break;}
case 40:
#line 183 "mcpparse.y"
{ yyval.stmt = makeStatement(STMT_BREAK, NULL); ;
    break;}
case 41:
#line 184 "mcpparse.y"
{ yyerror("missing ;"); yyval.stmt = makeNull(); ;
    break;}
case 42:
#line 185 "mcpparse.y"
{ yyval.stmt = makeStatement(STMT_CONT, NULL); ;
    break;}
case 43:
#line 186 "mcpparse.y"
{ yyerror("missing ;"); yyval.stmt = makeNull(); ;
    break;}
case 44:
#line 187 "mcpparse.y"
{ insertVar(PIECE_LVAR, yyvsp[-1].ilist); yyval.stmt = makeNull(); ;
    break;}
case 45:
#line 188 "mcpparse.y"
{ yyerror("missing ;"); yyval.stmt = makeNull(); ;
    break;}
case 46:
#line 189 "mcpparse.y"
{ yyval.stmt = yyvsp[-1].stmt; ;
    break;}
case 47:
#line 190 "mcpparse.y"
{ yyval.stmt = makeIf(yyvsp[-2].stmt, yyvsp[0].stmt, NULL); ;
    break;}
case 48:
#line 191 "mcpparse.y"
{ yyerror("missing ("); yyval.stmt = makeNull(); ;
    break;}
case 49:
#line 192 "mcpparse.y"
{ yyerror("invalid expression"); yyval.stmt = makeNull(); ;
    break;}
case 50:
#line 193 "mcpparse.y"
{
          yyerror("bogus statement");
          yyval.stmt = makeNull();
      ;
    break;}
case 51:
#line 197 "mcpparse.y"
{
          yyval.stmt = makeIf(yyvsp[-4].stmt, yyvsp[-2].stmt, yyvsp[0].stmt);
      ;
    break;}
case 52:
#line 200 "mcpparse.y"
{
          yyerror("bogus statement");
          yyval.stmt = makeNull();
      ;
    break;}
case 53:
#line 204 "mcpparse.y"
{
          yyval.stmt = makeLoop(LOOP_DO, NULL, yyvsp[-5].stmt, yyvsp[-2].stmt, NULL);
      ;
    break;}
case 54:
#line 207 "mcpparse.y"
{ yyerror("bogus statement"); yyval.stmt = makeNull(); ;
    break;}
case 55:
#line 208 "mcpparse.y"
{
          yyerror("expected while");
          yyval.stmt = makeNull();
      ;
    break;}
case 56:
#line 212 "mcpparse.y"
{
          yyerror("missing (");
          yyval.stmt = makeNull();
      ;
    break;}
case 57:
#line 216 "mcpparse.y"
{
          yyerror("missing )");
          yyval.stmt = makeNull();
      ;
    break;}
case 58:
#line 220 "mcpparse.y"
{
          yyerror("missing ;");
          yyval.stmt = makeNull();
      ;
    break;}
case 59:
#line 224 "mcpparse.y"
{
          yyval.stmt = makeLoop(LOOP_WHILE, NULL, yyvsp[0].stmt, yyvsp[-2].stmt, NULL);
      ;
    break;}
case 60:
#line 227 "mcpparse.y"
{ yyerror("missing ("); yyval.stmt = makeNull(); ;
    break;}
case 61:
#line 228 "mcpparse.y"
{ yyerror("missing )"); yyval.stmt = makeNull(); ;
    break;}
case 62:
#line 229 "mcpparse.y"
{
          yyerror("bogus statement");
          yyval.stmt = makeNull();
      ;
    break;}
case 63:
#line 233 "mcpparse.y"
{
          yyval.stmt = makeLoop(LOOP_FOR, yyvsp[-6].stmt, yyvsp[0].stmt, yyvsp[-4].stmt, yyvsp[-2].stmt);
      ;
    break;}
case 64:
#line 236 "mcpparse.y"
{ yyerror("missing ("); yyval.stmt = makeNull(); ;
    break;}
case 65:
#line 237 "mcpparse.y"
{ yyerror("missing ;"); yyval.stmt = makeNull(); ;
    break;}
case 66:
#line 238 "mcpparse.y"
{
          yyerror("missing ;");
          yyval.stmt = makeNull();
      ;
    break;}
case 67:
#line 242 "mcpparse.y"
{
          yyerror("missing )");
          yyval.stmt = makeNull();
      ;
    break;}
case 68:
#line 246 "mcpparse.y"
{
          yyerror("bogus statement");
          yyval.stmt = makeNull();
      ;
    break;}
case 69:
#line 250 "mcpparse.y"
{
          mcp_caselist *tmp = yyvsp[-1].clist;
          int had_error = 0;
          if(tmp->e != NULL) {
              tmp = tmp->next;
              while(tmp) {
                 if(tmp->e == NULL) {
                     yyerror("default case must come last");
                     had_error = 1;
                 }
                 tmp = tmp->next;
              }
          }
          if(had_error)
              yyval.stmt = makeNull();
          else
              yyval.stmt = makeSwitch(yyvsp[-6].val, yyvsp[-4].expr, yyvsp[-1].clist);
      ;
    break;}
case 70:
#line 268 "mcpparse.y"
{ yyerror("missing ("); yyval.stmt = makeNull(); ;
    break;}
case 71:
#line 269 "mcpparse.y"
{ yyerror("invalid expression"); yyval.stmt = makeNull(); ;
    break;}
case 72:
#line 270 "mcpparse.y"
{ yyerror("missing )"); yyval.stmt = makeNull(); ;
    break;}
case 73:
#line 271 "mcpparse.y"
{ yyerror("missing {"); yyval.stmt=makeNull(); ;
    break;}
case 74:
#line 272 "mcpparse.y"
{
          yyerror("invalid case");
          yyval.stmt=makeNull();
      ;
    break;}
case 75:
#line 276 "mcpparse.y"
{
          yyerror("missing }");
          yyval.stmt=makeNull();
      ;
    break;}
case 76:
#line 283 "mcpparse.y"
{ yyval.val = 0; ;
    break;}
case 77:
#line 284 "mcpparse.y"
{ yyval.val = 1; ;
    break;}
case 78:
#line 288 "mcpparse.y"
{ yyval.clist = yyvsp[0].clist; ;
    break;}
case 79:
#line 289 "mcpparse.y"
{ yyval.clist = appendCase(yyvsp[0].clist, yyvsp[-1].clist); ;
    break;}
case 80:
#line 290 "mcpparse.y"
{ yyval.clist = appendCase(yyvsp[0].clist, yyvsp[-1].clist); ;
    break;}
case 81:
#line 294 "mcpparse.y"
{ yyval.clist = makeCase(yyvsp[-2].expr, yyvsp[0].stmt); ;
    break;}
case 82:
#line 298 "mcpparse.y"
{ yyval.clist = makeCase(NULL, yyvsp[0].stmt); ;
    break;}
case 83:
#line 302 "mcpparse.y"
{ yyval.stmt = yyvsp[0].stmt; ;
    break;}
case 84:
#line 303 "mcpparse.y"
{ yyval.stmt = appendStatement(yyvsp[0].stmt, yyvsp[-1].stmt); ;
    break;}
case 85:
#line 307 "mcpparse.y"
{ yyval.stmt = makeNull(); ;
    break;}
case 86:
#line 308 "mcpparse.y"
{ yyval.stmt = makeStatement(STMT_EXPR, yyvsp[0].expr); ;
    break;}
case 87:
#line 309 "mcpparse.y"
{ yyval.stmt = yyvsp[0].stmt; ;
    break;}
case 88:
#line 313 "mcpparse.y"
{
          if(yyvsp[0].expr)
             yyval.stmt = makeAssign(yyvsp[-2].ilist, yyvsp[0].expr);
          else {
             yyerror("missing expression in assignment");
             yyval.stmt = makeNull();
          }
      ;
    break;}
case 89:
#line 324 "mcpparse.y"
{ yyval.expr = makeNumber(yyvsp[0].val); ;
    break;}
case 90:
#line 325 "mcpparse.y"
{ yyval.expr = makeObject(yyvsp[0].string); ;
    break;}
case 91:
#line 326 "mcpparse.y"
{ yyval.expr = makeString(yyvsp[0].string); ;
    break;}
case 92:
#line 327 "mcpparse.y"
{ yyval.expr = makeTop(); ;
    break;}
case 93:
#line 328 "mcpparse.y"
{ yyval.expr = makeIdent(yyvsp[0].string); ;
    break;}
case 94:
#line 329 "mcpparse.y"
{ yyval.expr = makeArrayRef(yyvsp[-3].string, yyvsp[-1].expr); ;
    break;}
case 95:
#line 330 "mcpparse.y"
{ yyerror("invalid expression"); yyval.expr = NULL; ;
    break;}
case 96:
#line 331 "mcpparse.y"
{ yyerror("missing ]"); yyval.expr = NULL; ;
    break;}
case 97:
#line 332 "mcpparse.y"
{ yyval.expr = makeIncr(EXPR_INC, yyvsp[-1].string); ;
    break;}
case 98:
#line 333 "mcpparse.y"
{ yyval.expr = makeIncr(EXPR_DEC, yyvsp[-1].string); ;
    break;}
case 99:
#line 334 "mcpparse.y"
{ yyval.expr = yyvsp[-1].expr; ;
    break;}
case 100:
#line 335 "mcpparse.y"
{ yyerror("expected )"); yyval.expr = NULL; ;
    break;}
case 101:
#line 336 "mcpparse.y"
{ yyval.expr = makeOp(OR, yyvsp[-2].expr, yyvsp[0].expr); ;
    break;}
case 102:
#line 337 "mcpparse.y"
{ yyval.expr = makeOp(AND, yyvsp[-2].expr, yyvsp[0].expr); ;
    break;}
case 103:
#line 338 "mcpparse.y"
{ yyval.expr = makeOp(ADD, yyvsp[-2].expr, yyvsp[0].expr); ;
    break;}
case 104:
#line 339 "mcpparse.y"
{ yyval.expr = makeOp(SUB, yyvsp[-2].expr, yyvsp[0].expr); ;
    break;}
case 105:
#line 340 "mcpparse.y"
{ yyval.expr = makeOp(MUL, yyvsp[-2].expr, yyvsp[0].expr); ;
    break;}
case 106:
#line 341 "mcpparse.y"
{ yyval.expr = makeOp(DIV, yyvsp[-2].expr, yyvsp[0].expr); ;
    break;}
case 107:
#line 342 "mcpparse.y"
{ yyval.expr = makeOp(MOD, yyvsp[-2].expr, yyvsp[0].expr); ;
    break;}
case 108:
#line 343 "mcpparse.y"
{ yyval.expr = makeOp(BITAND, yyvsp[-2].expr, yyvsp[0].expr); ;
    break;}
case 109:
#line 344 "mcpparse.y"
{ yyval.expr = makeOp(BITOR, yyvsp[-2].expr, yyvsp[0].expr); ;
    break;}
case 110:
#line 345 "mcpparse.y"
{ yyval.expr = makeOp(BITXOR, yyvsp[-2].expr, yyvsp[0].expr); ;
    break;}
case 111:
#line 346 "mcpparse.y"
{ yyval.expr = makeOp(SHIFTR, yyvsp[-2].expr, yyvsp[0].expr); ;
    break;}
case 112:
#line 347 "mcpparse.y"
{ yyval.expr = makeOp(SHIFTL, yyvsp[-2].expr, yyvsp[0].expr); ;
    break;}
case 113:
#line 348 "mcpparse.y"
{ yyval.expr = makeOp(GT, yyvsp[-2].expr, yyvsp[0].expr); ;
    break;}
case 114:
#line 349 "mcpparse.y"
{ yyval.expr = makeOp(GTE, yyvsp[-2].expr, yyvsp[0].expr); ;
    break;}
case 115:
#line 350 "mcpparse.y"
{ yyval.expr = makeOp(LT, yyvsp[-2].expr, yyvsp[0].expr); ;
    break;}
case 116:
#line 351 "mcpparse.y"
{ yyval.expr = makeOp(LTE, yyvsp[-2].expr, yyvsp[0].expr); ;
    break;}
case 117:
#line 352 "mcpparse.y"
{ yyval.expr = makeOp(EQ, yyvsp[-2].expr, yyvsp[0].expr); ;
    break;}
case 118:
#line 353 "mcpparse.y"
{ yyval.expr = makeOp(NE, yyvsp[-2].expr, yyvsp[0].expr); ;
    break;}
case 119:
#line 354 "mcpparse.y"
{ yyval.expr = makeOp(SUB, yyvsp[0].expr, NULL); ;
    break;}
case 120:
#line 355 "mcpparse.y"
{ yyval.expr = makeOp(NOT, yyvsp[0].expr, NULL); ;
    break;}
case 121:
#line 356 "mcpparse.y"
{ yyval.expr = makePush(yyvsp[-1].elist); ;
    break;}
case 122:
#line 357 "mcpparse.y"
{ yyerror("missing )"); yyval.expr = NULL; ;
    break;}
case 123:
#line 358 "mcpparse.y"
{ yyerror("missing )"); yyval.expr = NULL; ;
    break;}
case 124:
#line 359 "mcpparse.y"
{ yyval.expr = makeCall(yyvsp[-3].string, yyvsp[-1].elist, NULL); ;
    break;}
case 125:
#line 360 "mcpparse.y"
{ yyerror("missing )"); yyval.expr = NULL; ;
    break;}
case 126:
#line 361 "mcpparse.y"
{ yyval.expr = makeCall(yyvsp[-3].string, yyvsp[-1].elist, yyvsp[-5].string); ;
    break;}
case 127:
#line 362 "mcpparse.y"
{ yyerror("expected identifier"); yyval.expr = NULL; ;
    break;}
case 128:
#line 363 "mcpparse.y"
{ yyerror("missing )"); yyval.expr = NULL; ;
    break;}
case 129:
#line 364 "mcpparse.y"
{ yyerror("missing )"); yyval.expr = NULL; ;
    break;}
case 130:
#line 368 "mcpparse.y"
{ yyval.val = 0; ;
    break;}
case 131:
#line 369 "mcpparse.y"
{ yyval.val = 1; ;
    break;}
case 132:
#line 373 "mcpparse.y"
{
          insertFunction(yyvsp[-4].string, yyvsp[-2].ilist, yyvsp[0].stmt);
          if(yyvsp[-6].val)
              insertPublicDecl(yyvsp[-4].string);
          yyval.val = 0;
      ;
    break;}
case 133:
#line 379 "mcpparse.y"
{ yyerror("missing identifier"); yyval.val = 0; ;
    break;}
case 134:
#line 380 "mcpparse.y"
{ yyerror("missing ("); yyval.val = 0; ;
    break;}
case 135:
#line 381 "mcpparse.y"
{ yyerror("missing )"); yyval.val = 0; ;
    break;}
case 136:
#line 382 "mcpparse.y"
{
          yyerror("bogus statement"); yyval.val = 0;
      ;
    break;}
case 137:
#line 388 "mcpparse.y"
{ yyval.elist = makeExpr(NULL) ;
    break;}
case 138:
#line 389 "mcpparse.y"
{ yyval.elist = makeExpr(yyvsp[0].expr); ;
    break;}
case 139:
#line 390 "mcpparse.y"
{ yyval.elist = appendExpr(yyvsp[0].expr, yyvsp[-2].elist); ;
    break;}
case 140:
#line 394 "mcpparse.y"
{ yyval.ilist = makeBlank() ;
    break;}
case 141:
#line 395 "mcpparse.y"
{ yyval.ilist = makeId(yyvsp[0].string); ;
    break;}
case 142:
#line 396 "mcpparse.y"
{ yyval.ilist = makeArray(yyvsp[-3].string, yyvsp[-1].expr); ;
    break;}
case 143:
#line 397 "mcpparse.y"
{ yyerror("invalid expr"); yyval.ilist = makeBlank(); ;
    break;}
case 144:
#line 398 "mcpparse.y"
{ yyerror("missing ]"); yyval.ilist = makeBlank(); ;
    break;}
case 145:
#line 399 "mcpparse.y"
{ yyval.ilist = appendId(makeId(yyvsp[0].string), yyvsp[-2].ilist); ;
    break;}
case 146:
#line 400 "mcpparse.y"
{
          yyval.ilist = appendId(makeArray(yyvsp[-3].string, yyvsp[-1].expr), yyvsp[-5].ilist);
      ;
    break;}
case 147:
#line 403 "mcpparse.y"
{
          yyerror("invalid expression");
          yyval.ilist = makeBlank();
      ;
    break;}
case 148:
#line 407 "mcpparse.y"
{
          yyerror("missing ]");
          yyval.ilist = makeBlank();
      ;
    break;}
case 149:
#line 411 "mcpparse.y"
{ yyval.ilist = appendId(makeBlank(), yyvsp[-2].ilist); ;
    break;}
case 150:
#line 415 "mcpparse.y"
{ yyval.ilist = makeId(NULL) ;
    break;}
case 151:
#line 416 "mcpparse.y"
{ yyval.ilist = yyvsp[0].ilist; ;
    break;}
}
   /* the action file gets copied in in place of this dollarsign */
#line 487 "/usr/lib/bison.simple"

  yyvsp -= yylen;
  yyssp -= yylen;
#ifdef YYLSP_NEEDED
  yylsp -= yylen;
#endif

#if YYDEBUG != 0
  if (yydebug)
    {
      short *ssp1 = yyss - 1;
      fprintf (stderr, "state stack now");
      while (ssp1 != yyssp)
	fprintf (stderr, " %d", *++ssp1);
      fprintf (stderr, "\n");
    }
#endif

  *++yyvsp = yyval;

#ifdef YYLSP_NEEDED
  yylsp++;
  if (yylen == 0)
    {
      yylsp->first_line = yylloc.first_line;
      yylsp->first_column = yylloc.first_column;
      yylsp->last_line = (yylsp-1)->last_line;
      yylsp->last_column = (yylsp-1)->last_column;
      yylsp->text = 0;
    }
  else
    {
      yylsp->last_line = (yylsp+yylen-1)->last_line;
      yylsp->last_column = (yylsp+yylen-1)->last_column;
    }
#endif

  /* Now "shift" the result of the reduction.
     Determine what state that goes to,
     based on the state we popped back to
     and the rule number reduced by.  */

  yyn = yyr1[yyn];

  yystate = yypgoto[yyn - YYNTBASE] + *yyssp;
  if (yystate >= 0 && yystate <= YYLAST && yycheck[yystate] == *yyssp)
    yystate = yytable[yystate];
  else
    yystate = yydefgoto[yyn - YYNTBASE];

  goto yynewstate;

yyerrlab:   /* here on detecting error */

  if (! yyerrstatus)
    /* If not already recovering from an error, report this error.  */
    {
      ++yynerrs;

#ifdef YYERROR_VERBOSE
      yyn = yypact[yystate];

      if (yyn > YYFLAG && yyn < YYLAST)
	{
	  int size = 0;
	  char *msg;
	  int x, count;

	  count = 0;
	  /* Start X at -yyn if nec to avoid negative indexes in yycheck.  */
	  for (x = (yyn < 0 ? -yyn : 0);
	       x < (sizeof(yytname) / sizeof(char *)); x++)
	    if (yycheck[x + yyn] == x)
	      size += strlen(yytname[x]) + 15, count++;
	  msg = (char *) malloc(size + 15);
	  if (msg != 0)
	    {
	      strcpy(msg, "parse error");

	      if (count < 5)
		{
		  count = 0;
		  for (x = (yyn < 0 ? -yyn : 0);
		       x < (sizeof(yytname) / sizeof(char *)); x++)
		    if (yycheck[x + yyn] == x)
		      {
			strcat(msg, count == 0 ? ", expecting `" : " or `");
			strcat(msg, yytname[x]);
			strcat(msg, "'");
			count++;
		      }
		}
	      yyerror(msg);
	      free(msg);
	    }
	  else
	    yyerror ("parse error; also virtual memory exceeded");
	}
      else
#endif /* YYERROR_VERBOSE */
	yyerror("parse error");
    }

  goto yyerrlab1;
yyerrlab1:   /* here on error raised explicitly by an action */

  if (yyerrstatus == 3)
    {
      /* if just tried and failed to reuse lookahead token after an error, discard it.  */

      /* return failure if at end of input */
      if (yychar == YYEOF)
	YYABORT;

#if YYDEBUG != 0
      if (yydebug)
	fprintf(stderr, "Discarding token %d (%s).\n", yychar, yytname[yychar1]);
#endif

      yychar = YYEMPTY;
    }

  /* Else will try to reuse lookahead token
     after shifting the error token.  */

  yyerrstatus = 3;		/* Each real token shifted decrements this */

  goto yyerrhandle;

yyerrdefault:  /* current state does not do anything special for the error token. */

#if 0
  /* This is wrong; only states that explicitly want error tokens
     should shift them.  */
  yyn = yydefact[yystate];  /* If its default is to accept any token, ok.  Otherwise pop it.*/
  if (yyn) goto yydefault;
#endif

yyerrpop:   /* pop the current state because it cannot handle the error token */

  if (yyssp == yyss) YYABORT;
  yyvsp--;
  yystate = *--yyssp;
#ifdef YYLSP_NEEDED
  yylsp--;
#endif

#if YYDEBUG != 0
  if (yydebug)
    {
      short *ssp1 = yyss - 1;
      fprintf (stderr, "Error: state stack now");
      while (ssp1 != yyssp)
	fprintf (stderr, " %d", *++ssp1);
      fprintf (stderr, "\n");
    }
#endif

yyerrhandle:

  yyn = yypact[yystate];
  if (yyn == YYFLAG)
    goto yyerrdefault;

  yyn += YYTERROR;
  if (yyn < 0 || yyn > YYLAST || yycheck[yyn] != YYTERROR)
    goto yyerrdefault;

  yyn = yytable[yyn];
  if (yyn < 0)
    {
      if (yyn == YYFLAG)
	goto yyerrpop;
      yyn = -yyn;
      goto yyreduce;
    }
  else if (yyn == 0)
    goto yyerrpop;

  if (yyn == YYFINAL)
    YYACCEPT;

#if YYDEBUG != 0
  if (yydebug)
    fprintf(stderr, "Shifting error token, ");
#endif

  *++yyvsp = yylval;
#ifdef YYLSP_NEEDED
  *++yylsp = yylloc;
#endif

  yystate = yyn;
  goto yynewstate;
}
#line 419 "mcpparse.y"


#ifndef TEST
dbref cur_player;

extern FILE *yyin;
#endif

int yylinenum;
static int parse_error;
static int expected_line;
static int expected_other_error;

#ifndef TEST
int convert (char *infile, char *outfile, dbref player)
#else
int convert(void)
#endif
{
#ifndef TEST
    FILE *outf;

    cur_player = player;
    yyin = fopen(infile, "r");
    if(!yyin) return -1;

    outf = fopen(outfile, "w");
    if(!outf) return -2;
#endif

    yylinenum = 1;
    parse_error = 0;
    expected_line = 0;
    expected_other_error = 0;

    initMcpParser();
    yyparse();
    if(expected_other_error) {
        yylinenum = expected_line;
        yyerror("unexpected parse error");
    }
    if(!parse_error)
#ifdef TEST
        writeMcpProgram(stdout);
#else
        writeMcpProgram(outf);
    fclose(yyin);
    fclose(outf);
#endif
    clearMem();

    return ( (parse_error) ? -3 : 0);
}

void yyerror(char *arg)
{
    char buf[1024];
    if(strcmp(arg, "parse error") == 0) {
        expected_other_error = 1;
        expected_line = yylinenum;
        return;
    }
    sprintf(buf, "(line %d) Error: %s\n", yylinenum, arg);
#ifdef TEST
    fprintf(stderr, "%s",  buf);
#else
    notify(cur_player,  buf);
#endif
    parse_error = 1;
    expected_other_error = 0;
}

void yywarn(char *arg)
{
    char buf[1024];
    sprintf(buf, "(line %d) Warning: %s\n", yylinenum, arg);
#ifdef TEST
    fprintf(stderr, "%s",  buf);
#else
    notify(cur_player, buf);
#endif
}

#ifdef TEST
void main(void)
{
    convert();
}
#endif
